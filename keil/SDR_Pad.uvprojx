# Keil uVision project SDR_Pad.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.1
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SDR_Pad
  AfterMake: fromelf -cvf .\SDR_Pad.axf --vhx --32x1 -o code.hex
  AfterMake: fromelf -cvf .\SDR_Pad.axf -o code.txt
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Source Group 1
    ../src/: main.c Asset.h RealTank.h startup_CMSDK_CM0.s data.h
    ../src/Driver/: Buzzer.c Buzzer.h code_def.c code_def.h LCD.c LCD.h Timer.c Timer.h UART.c UART.h SPI.c SPI.h Tube.c Tube.h DETECTOR.h I2C.c I2C.h Ethernet.c Ethernet.h ledwater.c ledwater.h
    ../src/GameSDK/: Game.c Game.h
